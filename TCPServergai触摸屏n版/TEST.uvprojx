# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\System\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USR
    ./USR/: main.c stm32f10x_it.c gpio_config.c usart_config.c nvic_config.c ESP8266.c led.c key.c lcd.c dht11.c beep.c adc.c timer.c stmflash.c oled.c ctiic.c gt9147.c pbdata.c myiic.c ott2001a.c touch.c 24cxx.c
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group LIB
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_spi.c
  group SYSTEM
    ./System/: core_cm3.c system_stm32f10x.c
    ./System/sys/: sys.c
